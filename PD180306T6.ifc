Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Project Number
Time: 2021-07-22T11:12:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 22 11:12:39 2021 * Host: DESKTOP-Q5LSCDT * Database: C:\Users\ADMINI~1\AppData\Local\Temp\f044b418-1930-4244-b5cd-d488d4981c78\05ca11a5-7d66-4452-a32e-d2ae1411a336\ifc * Database version: 5507 * Database creation date: Thu Jul 22 11:12:38 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 22 11:12:38 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 22 11:12:38 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 28, 36, 29, 808654; RefLongitude: 77, 12, 2, 927856; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:6mm Head, 01
LongName: 01; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 6mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle-6mm: M_Level Head - Circle-6mm; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Other - Category: Levels; Family: Level: 6mm Head; Family and Type: Level: 6mm Head; Type: Level: 6mm Head; Type Id: Level: 6mm Head
Pset_AirSideSystemInformation - Name: 01
Pset_ProductRequirements - Name: 01; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 01; Structural: no

# IfcBuildingElementProxy: PD180306T6, PD180306T6:PD180306T6:217242
In: 01
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Manufacturer: RECENSE; Model: PD180306T6; Type Name: PD180306T6; URL: www.recenseterwa.com
Type - Materials and Finishes - Acabado: Zincado Electrolítico; Material: Acero S275JR
Type - Other - Category: Generic Models; Family Name: PD180306T6
Type - Pset_BuildingElementProxyCommon - Reference: PD180306T6:PD180306T6
Type - Pset_ManufacturerTypeInformation - Manufacturer: RECENSE
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: PD180306T6:PD180306T6
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Host: Level : 01; Level: Level: 01; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0073497 m2; Volume: 0.0000284758 m3
Other - Family: PD180306T6: PD180306T6; Family and Type: PD180306T6: PD180306T6; Type: PD180306T6: PD180306T6; Type Id: PD180306T6: PD180306T6
Phasing - Phase Created: New Construction

# IfcOpeningElement: Opening (2)
In: 01
BaseQuantities - Depth: 30 mm; Area: 0.00096 m2
Pset_ManufacturerTypeInformation - Manufacturer: RECENSE
Pset_OpeningElementCommon - Reference: PD180306T6:PD180306T6; sets with these values: 2
Pset_ProductRequirements - Category: Generic Models
Name (PD180306T6:PD180306T6:217242:...)
1
2
