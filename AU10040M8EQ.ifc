Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2018-11-05T15:22:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 05 15:22:58 2018 * Host: DESKTOP-0D0FPG2 * Database: C:\Users\MAQUIN~1\AppData\Local\Temp\{223A0973-D374-410E-8DF6-6E5540475F82}\ifc * Database version: 5507 * Database creation date: Mon Nov 05 15:22:57 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 05 15:22:57 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 05 15:22:57 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Otros - Categoría: Información de proyecto; Dirección de proyecto: Introduzca dirección aquí; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: 0001

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Restricciones(Type) - Altura base: Punto base del proyecto
Otros(Type) - Categoría: Niveles; Nombre de familia: Nivel
Cotas - Altura de cálculo: 0 mm
Datos de identidad - Estructura: no; Nombre: Nivel 1; Planta de edificio: yes
Otros - Categoría: Niveles; Familia: Nivel: Extremo inicial 8 mm; Familia y tipo: Nivel: Extremo inicial 8 mm; ID de tipo: Nivel: Extremo inicial 8 mm; Tipo: Nivel: Extremo inicial 8 mm
Restricciones - Alzado: 0 mm
Datos de identidad(Type) - Nombre de tipo: Extremo inicial 8 mm
Gráficos(Type) - Color: 0; Grosor de línea: 1; Patrón de línea: Centro; Símbolo: M_Extremo inicial de nivel - Círculo: M_Extremo inicial de nivel - Círculo; Símbolo en extremo 1 por defecto: no; Símbolo en extremo 2 por defecto: yes

# IfcBuildingElementProxy: AU10040M8EQ, AU10040M8EQ:AU10040M8EQ:334966
In: Nivel 1
Type - Datos de identidad - Fabricante: RECENSE; Modelo: AU10040M8EQ; Nombre de tipo: AU10040M8EQ; URL: www.terwarecense.com
Type - Materiales y acabados - Acabado: Zincado; Material: Acero
Type - Otros - Categoría: Modelos genéricos; Nombre de familia: AU10040M8EQ
Pset_BuildingElementProxyCommon - Reference: AU10040M8EQ:AU10040M8EQ
Pset_ManufacturerTypeInformation - Manufacturer: RECENSE
Cotas - Área: 0.00267419 m2; Volumen: 0.00000964501 m3
Otros - Familia: AU10040M8EQ: AU10040M8EQ; Familia y tipo: AU10040M8EQ: AU10040M8EQ; ID de tipo: AU10040M8EQ: AU10040M8EQ; Tipo: AU10040M8EQ: AU10040M8EQ
Proceso por fases - Fase de creación: Nueva construcción
Restricciones - Anfitrión: Nivel : Nivel 1; Desfase: 0 mm; Nivel: Nivel: Nivel 1; Se mueve con elementos cercanos: no
